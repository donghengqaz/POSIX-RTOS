# IAR project STM32F746G-DISCO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: STM32F746xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\hwutil\kernel\include; ..\..\..\hwutil\kernel\definition; ..\..\..\hwutil\drivers\fb\include; ..\..\..\hwutil\drivers\input\include; ..\..\..\hwutil\drivers\led\include; ..\..\..\hwutil\net\lwip\src\include; ..\..\..\hwutil\net\lwip\src\include\ipv4; ..\..\..\hwutil\net\lwip\src\include\port; ..\..\..\hwutil\net\port\include; ..\..\..\bsp\arch\ARM\Cortex-M\Common\include; ..\..\..\bsp\arch\ARM\Cortex-M\M7\CMSIS\include; ..\..\..\bsp\arch\ARM\Cortex-M\M7\cpuport\include; ..\..\..\bsp\arch\ARM\Cortex-M\M7\chip\ST\STM32F7\STM32F7xx_HAL_Driver\include; ..\..\..\bsp\board\ST\STM32F746G-DISCO\hal\include; ..\main\include; ..\..\..\hwutil\fs\fatfs\include; ..\..\..\hwutil\shell\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F746G-DISCO.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\..\bsp\board\ST\STM32F746G-DISCO\linker\STM32F746G-DISCO.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group BSP/chip/include
    ../../../bsp/arch/ARM/Cortex-M/M7/chip/ST/STM32F7/STM32F7xx_HAL_Driver/include/: stm32f745xx.h stm32f746xx.h stm32f756xx.h stm32f7xx.h stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_conf.h stm32f7xx_hal_conf_template.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_fmc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_usb.h system_stm32f7xx.h
  group BSP/chip/source
    ../../../bsp/arch/ARM/Cortex-M/M7/chip/ST/STM32F7/Startup/iar/: startup_stm32f746xx.s
    ../../../bsp/arch/ARM/Cortex-M/M7/chip/ST/STM32F7/STM32F7xx_HAL_Driver/source/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c system_stm32f7xx.c
  group BSP/CPU/CMSIS/include
    ../../../bsp/arch/ARM/Cortex-M/M7/CMSIS/include/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group BSP/CPU/cpuport/include
    ../../../bsp/arch/ARM/Cortex-M/M7/cpuport/include/: cpuport.h spinlock.h
  group BSP/CPU/cpuport/source
    ../../../bsp/arch/ARM/Cortex-M/M7/cpuport/source/: cpuport.c text_switch.s
  group BSP/hal
    ../../../bsp/board/ST/STM32F746G-DISCO/hal/source/: cache.c chip_test.c clk.c irq.c key.c led.c low_level.c sys_tick.c uart.c
  group BSP/link
    ../../../bsp/board/ST/STM32F746G-DISCO/linker/: STM32F746G-DISCO.icf
  group POSIX-RTOS/driver/input
    ../../../hwutil/drivers/input/source/: input.c
  group POSIX-RTOS/driver/led
    ../../../hwutil/drivers/led/source/: led_trigger.c
  group POSIX-RTOS/kernel
    ../../../hwutil/kernel/source/: hal.c idle.c init.c mqueue.c pthread.c sched.c semaphore.c signal.c stdio.c stdlib.c string.c time.c unistd.c
  group POSIX-RTOS/net/LWIP
    ../../../hwutil/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../hwutil/net/lwip/src/core/: def.c dhcp.c dns.c lwip_init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../hwutil/net/lwip/src/netif/: etharp.c
  group POSIX-RTOS/net/port/include
    ../../../hwutil/net/port/include/: ippkg.h ipport.h ipport_def.h ipthread.h
  group POSIX-RTOS/net/port/source
    ../../../hwutil/net/port/soure/: ippkg.c ipport.c ipthread.c
  group POSIX-RTOS/shell/include
    ../../../hwutil/shell/include/: shell.h shell_def.h
  group POSIX-RTOS/shell/source
    ../../../hwutil/shell/source/: shell.c
  group main/source
    ../main/source/: app.c main.c
